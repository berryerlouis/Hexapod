////////////////////////////////////////INCLUDES//////////////////////////////////////////////////
#include   "SnrGPS.h"

#ifdef GPS_VENUS638LPX
	#include   "Cmps/CmpVENUS638LPX.h"
#endif // #define 
////////////////////////////////////////PRIVATE DEFINES///////////////////////////////////////////

////////////////////////////////////////PRIVATE STRUCTURES////////////////////////////////////////

////////////////////////////////////////PRIVATE FUNCTIONS/////////////////////////////////////////

////////////////////////////////////////PRIVATE VARIABLES/////////////////////////////////////////
static Gps gps;

////////////////////////////////////////PUBILC FUNCTIONS//////////////////////////////////////////
Boolean SnrGpsInit ( void )
{	
#ifdef GPS_VENUS638LPX
	gps.data = &venus638lpxData;
	gps.functions = &venus638lpx;
#endif // GPS_VENUS638LPX

	//init du composant
	if(gps.functions != NULL)
	{
		return  gps.functions->init();
	}
	return FALSE;
}

Boolean SnrGpsDecodeGPSFrame( void )
{
	if(gps.functions != NULL)
	{
		return gps.functions->readData();
	}	
	return FALSE;
}
GpsData* SnrGpsGetStruct( void )
{
	if(gps.data != NULL)
	{
		return gps.data;
	}
	return NULL;
}


////////////////////////////////////////PRIVATE FUNCTIONS/////////////////////////////////////////
